# Keil uVision project DriverBLDC.uvprojx, settings and files
target STM32F031C6 (6140000::V6.14::ARMCLANG)
  device: STM32F031C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: DriverBLDC +hex
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=9 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group common
    ./: main.c define.h
  group init
    ./: init.h init.c
  group delay
    ./: delay.h delay.c
  group led
    ./: led.h
  group phase
    ./: phase.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
